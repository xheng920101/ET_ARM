# Keil uVision project STM_DEMO.uvproj, settings and files
target STM_DEMO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM_DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,TM32F2XX
  c include: ..\FWlib\inc;..\CMSIS;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ../CMSIS/startup/: startup_stm32f2xx.s
  group FWlib
    ../FWlib/src/: stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_usart.c stm32f2xx_dma.c stm32f2xx_adc.c misc.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_sdio.c stm32f2xx_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f2xx.c
  group USER
    ../USER/: include.h main.c TaskPolling.C stm32f2xx_it.c sysTick.c board_conf.c usart.c timer.c admesy.c admesy_flicker.c admesy_filter.c kiss_fft.c adc.c i2c.c power.c digital_sensor.c eeprom.c led.c key.c ssd2828.c fpga.c lcd.c sdcard.c bsp_bmp.c lcd_test.c test_debug.c test_demo.c test_od.c test_et1.c test_et2.c test_et3.c test_otp.c test_ra.c test_esd.c test_ctp.c test_oqc1.c test_SDcard.c
  group INI_OTP
    ../../../自动线backup/TL060FVMS16-00 陈晓梦/: TL060FVMS16-00_initial code_TD4310_CMOS_V1.3.c TL060FVMS16-00_otp code_TD4310.c
  group FF9
    ../USER/ff9/: ff.c diskio.c
    ../USER/ff9/option/: ccsbcs.c
